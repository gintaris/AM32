# Keil uVision project Am32G431.uvprojx, settings and files
target G431_test (6230000::V6.23::ARMCLANG)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: AM32_REF_G431 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: REF_G431, USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G431xx
  c include: ..\Mcu\g431\Drivers\STM32G4xx_HAL_Driver\Inc;..\Mcu\g431\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\Inc;..\Mcu\g431\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\g431\Am32_64kb_g431.sct
  group startup
    ../Mcu/g431/Startup/: startup_stm32g431xx.s
  group Drivers
    ../Mcu/g431/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_adc.c stm32g4xx_ll_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_crc.c stm32g4xx_ll_crs.c stm32g4xx_ll_dac.c stm32g4xx_ll_dma.c stm32g4xx_ll_exti.c stm32g4xx_ll_fmac.c stm32g4xx_ll_gpio.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lptim.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_opamp.c stm32g4xx_ll_pwr.c stm32g4xx_ll_rcc.c stm32g4xx_ll_rng.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_ucpd.c stm32g4xx_ll_usart.c stm32g4xx_ll_utils.c
  group Src
    ../Src/: dshot.c firmwareversion.c functions.c main.c signal.c sounds.c kiss_telemetry.c
  group Mcu
    ../Mcu/g431/Src/: ADC.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c stm32g4xx_it.c system_stm32g4xx.c WS2812.c
  group DroneCAN
    ../Src/DroneCAN/: DroneCAN.c DroneCAN.h filter.c filter.h sys_can.h sys_can_stm32.c
    ../Src/DroneCAN/libcanard/: canard.c canard.h canard_internals.h
    ../Src/DroneCAN/dsdl_generated/: dronecan_msgs.h
    ../Src/DroneCAN/dsdl_generated/src/: dronecan.protocol.FlexDebug.c uavcan.equipment.esc.RawCommand.c uavcan.equipment.esc.RPMCommand.c uavcan.equipment.esc.Status.c uavcan.equipment.esc.StatusExtended.c uavcan.equipment.safety.ArmingStatus.c uavcan.protocol.debug.KeyValue.c uavcan.protocol.debug.LogLevel.c uavcan.protocol.debug.LogMessage.c uavcan.protocol.dynamic_node_id.Allocation.c uavcan.protocol.dynamic_node_id.server.AppendEntries_req.c uavcan.protocol.dynamic_node_id.server.AppendEntries_res.c uavcan.protocol.dynamic_node_id.server.Discovery.c uavcan.protocol.dynamic_node_id.server.Entry.c uavcan.protocol.dynamic_node_id.server.RequestVote_req.c uavcan.protocol.dynamic_node_id.server.RequestVote_res.c uavcan.protocol.file.BeginFirmwareUpdate_req.c uavcan.protocol.file.BeginFirmwareUpdate_res.c uavcan.protocol.file.Delete_req.c uavcan.protocol.file.Delete_res.c uavcan.protocol.file.EntryType.c uavcan.protocol.file.Error.c uavcan.protocol.file.GetDirectoryEntryInfo_req.c uavcan.protocol.file.GetDirectoryEntryInfo_res.c uavcan.protocol.file.GetInfo_req.c uavcan.protocol.file.GetInfo_res.c uavcan.protocol.file.Path.c uavcan.protocol.file.Read_req.c uavcan.protocol.file.Read_res.c uavcan.protocol.file.Write_req.c uavcan.protocol.file.Write_res.c uavcan.protocol.GetNodeInfo_req.c uavcan.protocol.GetNodeInfo_res.c uavcan.protocol.HardwareVersion.c uavcan.protocol.NodeStatus.c uavcan.protocol.param.Empty.c uavcan.protocol.param.ExecuteOpcode_req.c uavcan.protocol.param.ExecuteOpcode_res.c uavcan.protocol.param.GetSet_req.c uavcan.protocol.param.GetSet_res.c uavcan.protocol.param.NumericValue.c uavcan.protocol.param.Value.c uavcan.protocol.RestartNode_req.c uavcan.protocol.RestartNode_res.c uavcan.protocol.SoftwareVersion.c
    ../Src/DroneCAN/libcanard/drivers/stm32/: canard_stm32.c
target PhotonDrive_G431 (6230000::V6.23::ARMCLANG)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: AM32_PROTONDRIVE_G431 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: PROTONDRIVE_G431, USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G431xx
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\g431\Am32_64kb_g431.sct
target MB1419_G431 (6230000::V6.23::ARMCLANG)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: AM32_MB1419_G431 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: MB1419_G431, USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G431xx
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\g431\Am32_64kb_g431.sct
target MB1419_G431_CAN (6230000::V6.23::ARMCLANG)
  device: STM32G431KBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: as above
  output: AM32_MB1419_G431_CAN +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: MB1419_G431_CAN, USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32G431xx
  c include: ..\Mcu\g431\Drivers\STM32G4xx_HAL_Driver\Inc;..\Mcu\g431\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\Inc;..\Mcu\g431\Inc;..\Mcu\g431\Drivers\CMSIS\Include;..\Mcu\g431\Drivers\CMSIS\Core\Include;..\Src\DroneCAN;..\Src\DroneCAN\libcanard;..\Src\DroneCAN\dsdl_generated;..\Src\DroneCAN\dsdl_generated\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\Mcu\g431\Am32_64kb_g431.sct
software components: CMSIS:CORE 5.6.0
